# Keil uVision project I2C-Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C-Demo
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: .\Include;.\RTCS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: delay.c i2c_p1.c LEDs.c main.c mma8451.c timers.c
  group RTCS
    ./RTCS/: RTCS.c RTCS.h
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: as above
  output: I2C-Demo
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: .\Include;.\RTCS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
